# Keil uVision project UART1_RingBuffer.uvprojx, settings and files
target STM32F103C8 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: UART1_RingBuffer +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./: main.c main.h
  group Application
    ./: COMM_UART.h COMM_UART.c
software components: CMSIS:CORE 5.2.0, Device:Startup 1.0.0
